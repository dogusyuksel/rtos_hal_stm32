DESCRIPTION = "RTOS TIMER Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "TIMER"

PATCH_FILE = "/workspace/rtos/patches/timer.patch"
