DESCRIPTION = "RTOS Task Create Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "TASK_CREATE"

PATCH_FILE = "/workspace/patches/task_create_and_control.patch"
