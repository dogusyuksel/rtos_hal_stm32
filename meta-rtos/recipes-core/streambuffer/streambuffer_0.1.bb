DESCRIPTION = "RTOS STREAM BUFFER Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "STREAMBUFFER"

PATCH_FILE = "/workspace/patches/stream_buffer.patch"
