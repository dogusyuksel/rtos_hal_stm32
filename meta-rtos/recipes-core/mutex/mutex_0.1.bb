DESCRIPTION = "RTOS MUTEX Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "MUTEX"

PATCH_FILE = "/workspace/patches/notify_and_mutex.patch"
