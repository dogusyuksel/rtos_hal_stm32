DESCRIPTION = "RTOS Task Notify Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "TASK_NOTIFY"

PATCH_FILE = "/workspace/rtos/patches/kernel_control_task_notify.patch"
