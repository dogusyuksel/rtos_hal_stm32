DESCRIPTION = "RTOS QUEUE in ISR Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "QUEUE_IN_ISR"

PATCH_FILE = "/workspace/patches/queue_isr.patch"
