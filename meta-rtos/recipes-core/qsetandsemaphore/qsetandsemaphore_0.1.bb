DESCRIPTION = "RTOS QSET and SEMAPHORE Example"
SECTION = "rtos"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "QSET_AND_SEMAPHORE"

PATCH_FILE = "/workspace/rtos/patches/qset_semaphore.patch"
